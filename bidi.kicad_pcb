# Repository F6ITU/ampli-bidi

File README.md:

# ampli-bidi
A 50/50 Ohm 3dB gain low noise  bidirectional 10.7 MHz amplifier

This bidirectionnal amplifier has been developped by DK5LV to enhance the input stage of an IF amplifier. 
Description (in French) could be found at 
https://wiki.electrolab.fr/Projets:Lab:2011:Picastar#Modification_de_l.E2.80.99.C3.A9tage_d.E2.80.99adaptation_d.E2.80.99imp.C3.A9dance_du_filtre_.C3.A0_quartz

## KiCad design bidi.kicad_pcb

Parts:
C1, C3, C7, C8, C15, C17: 10n Wima
C2, C4, C5, C6, C9, C10, C11, C12, C13, C14, C16, C18, C19, C20: 100n
D1, D2, D3, D4: BAT18
L1, L2, L3, L4: 10u
R1, R2, R10, R11, R20, R21: 1k
R3, R15: 680
R4, R19: 47
R5, R18: 400
R6, R7, R16, R17: 2k2
R8, R13: 56
R9, R14: 10
R12, R24: 68
St1, St2, St3, St4, St5, St6, St8, St10: CONN_1
T1, T2, T3, T4: BFS20
TR1, TR2: ADT9-1

Connections:
GND: C2.2, C4.2, C5.2, C6.2, C9.1, C10.2, C11.2, C12.2, C13.1, C14.2, C16.1, C18.2, C19.2, C20.2, R1.1, R3.2, R8.2, R10.2, R13.2, R15.2, TR1.1, TR2.3
unnamed: R13.1, R14.1, T3.2 (E)
unnamed: C17.2, D4.1, R21.2
unnamed: C16.2, L4.2, R21.1
unnamed: L3.1, L4.1, R19.1, St6.1
unnamed: C13.2, R14.2
unnamed: C8.2, D2.3, R10.1, St4.1
unnamed: C20.1, R24.2
unnamed: C15.1, D3.1, R20.2
unnamed: C15.2, R15.1, R16.2, R24.1, T3.1 (B)
unnamed: R18.2, T4.3 (C), TR2.4
unnamed: T3.3 (C), T4.2 (E)
unnamed: D3.3, St8.1
unnamed: C1.2, D1.3, R1.2, St1.1
unnamed: D4.3, St10.1
unnamed: T1.2 (E), T2.3 (C)
unnamed: C7.1, TR1.3
unnamed: C17.1, TR2.1
unnamed: C6.1, R9.2
unnamed: C8.1, St5.1
unnamed: C1.1, St2.1
unnamed: C10.1, R12.2
unnamed: C3.1, D1.1, R2.2
unnamed: R5.2, T1.3 (C), TR1.6
unnamed: C5.1, R6.2, R7.1, T1.1 (B)
unnamed: L1.1, L2.1, R4.1, St3.1
unnamed: C3.2, R3.1, R7.2, R12.1, T2.1 (B)
unnamed: C2.1, L1.2, R2.1
unnamed: C4.1, C18.1, R4.2, R5.1, R6.1, TR1.4
unnamed: C12.1, R16.1, R17.2, T4.1 (B)
unnamed: C14.1, L3.2, R20.1
unnamed: C11.1, C19.1, R17.1, R18.1, R19.2, TR2.6
unnamed: R8.1, R9.1, T2.2 (E)
unnamed: C7.2, D2.1, R11.2
unnamed: C9.2, L2.2, R11.1

Notes on the sheet:
1/1
DK5LV Bidirectional I.F. amplifier
BAT18 : Anode pin 1 Cathode pin 3 SOT 23
BFS20 1 : Base 2 : Emitter 3 : Collector SOT23
Cap Wima : package 1812L
+12V TX
+12V RX
All 100nF decoupling cap 1206 otherwise noticed
Board to board external wired junction
ADT9-1 /T9-1-X65 sold by Funkamateur.de
10nH Inductance RS part 180-7880
R5/R18 - 400 Ohms avec ATD9-1 - 470 Ohms avec ATD8-1

Board: 2 copper layers, 64 parts (0 on the bottom side), 35 nets.

## Commit log

2017-01-20 reprise des activités, ajout bidi amp
